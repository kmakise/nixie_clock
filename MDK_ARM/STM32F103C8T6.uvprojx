# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target stm32f103C8T6_mode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NixieTube +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\Core;..\Application\Hardware\inc;..\Application\System\inc;..\Application\User\inc;..\Application\Amadeus\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/Amadeus/src
    ../Application/Amadeus/src/: AmadeusMain.c NixieApp.c
  group Application/Amadeus/inc
    ../Application/Amadeus/inc/: AmadeusMain.h NixieApp.h
  group Application/User/src
    ../Application/User/src/: main.c stm32f10x_it.c system_stm32f10x.c
  group Application/User/inc
    ../Application/User/inc/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group Application/Hardware/src
    ../Application/Hardware/src/: oled.c HighVoltage.c NixieTube.c KeyBoard.c LEDTimer.c DS3231.c Beep.c
  group Application/Hardware/inc
    ../Application/Hardware/inc/: bmp.h oled.h oledfont.h HighVoltage.h NixieTube.h KeyBoard.h LEDTimer.h DS3231.h Beep.h
  group Application/System/src
    ../Application/System/src/: delay.c sys.c usart.c tim.c
  group Application/System/inc
    ../Application/System/inc/: delay.h sys.h usart.h tim.h
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SysLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
